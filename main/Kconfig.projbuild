## main/Kconfig.projbuild
```kconfig
menu "Creeper Configuration"

    config CREEPER_VOLUME
        int "Output volume (percent)"
        range 1 100
        default 80

endmenu
```
